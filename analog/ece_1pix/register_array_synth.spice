* register_array.spice
* File autogenerated by json2spice.py

* Standard Cell Includes

* Subcircuit Definition
.subckt register_array clk reset enable count.0 count.1 count.2 count.3 count.4 count.5 count.6 count.7 stored_values.0 stored_values.1 stored_values.2 stored_values.3 stored_values.4 stored_values.5 stored_values.6 stored_values.7 VGND VNB VPB VPWR

* Standard Cells
x__0__ stored_values.0 count.0 enable VGND VNB VPB VPWR __21__ sky130_fd_sc_hs__mux2i_1
x__1__ reset __21__ VGND VNB VPB VPWR __22__ sky130_fd_sc_hs__nor2_1
x__2__ stored_values.1 count.1 enable VGND VNB VPB VPWR __23__ sky130_fd_sc_hs__mux2i_1
x__3__ reset __23__ VGND VNB VPB VPWR __24__ sky130_fd_sc_hs__nor2_1
x__4__ stored_values.2 count.2 enable VGND VNB VPB VPWR __25__ sky130_fd_sc_hs__mux2i_1
x__5__ reset __25__ VGND VNB VPB VPWR __26__ sky130_fd_sc_hs__nor2_1
x__6__ stored_values.3 count.3 enable VGND VNB VPB VPWR __27__ sky130_fd_sc_hs__mux2i_1
x__7__ reset __27__ VGND VNB VPB VPWR __28__ sky130_fd_sc_hs__nor2_1
x__8__ stored_values.4 count.4 enable VGND VNB VPB VPWR __29__ sky130_fd_sc_hs__mux2i_1
x__9__ reset __29__ VGND VNB VPB VPWR __30__ sky130_fd_sc_hs__nor2_1
x__10__ stored_values.5 count.5 enable VGND VNB VPB VPWR __31__ sky130_fd_sc_hs__mux2i_1
x__11__ reset __31__ VGND VNB VPB VPWR __32__ sky130_fd_sc_hs__nor2_1
x__12__ stored_values.6 count.6 enable VGND VNB VPB VPWR __33__ sky130_fd_sc_hs__mux2i_1
x__13__ reset __33__ VGND VNB VPB VPWR __34__ sky130_fd_sc_hs__nor2_1
x__14__ stored_values.7 count.7 enable VGND VNB VPB VPWR __35__ sky130_fd_sc_hs__mux2i_1
x__15__ reset __35__ VGND VNB VPB VPWR __36__ sky130_fd_sc_hs__nor2_1
x__16__ clk __22__ VGND VNB VPB VPWR stored_values.0 sky130_fd_sc_hs__dfxtp_1
x__17__ clk __24__ VGND VNB VPB VPWR stored_values.1 sky130_fd_sc_hs__dfxtp_1
x__18__ clk __26__ VGND VNB VPB VPWR stored_values.2 sky130_fd_sc_hs__dfxtp_1
x__19__ clk __28__ VGND VNB VPB VPWR stored_values.3 sky130_fd_sc_hs__dfxtp_1
x__20__ clk __30__ VGND VNB VPB VPWR stored_values.4 sky130_fd_sc_hs__dfxtp_1
x__21__ clk __32__ VGND VNB VPB VPWR stored_values.5 sky130_fd_sc_hs__dfxtp_1
x__22__ clk __34__ VGND VNB VPB VPWR stored_values.6 sky130_fd_sc_hs__dfxtp_1
x__23__ clk __36__ VGND VNB VPB VPWR stored_values.7 sky130_fd_sc_hs__dfxtp_1

* Tieoffs

.ends
