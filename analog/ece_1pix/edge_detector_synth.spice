* edge_detector.spice
* File autogenerated by json2spice.py

* Standard Cell Includes

* Subcircuit Definition
.subckt edge_detector clk reset comp enable VGND VNB VPB VPWR

* Standard Cells
x__0__ comp_prev comp VGND VNB VPB VPWR enable sky130_fd_sc_hs__nor2b_1
x__1__ reset comp VGND VNB VPB VPWR __7__ sky130_fd_sc_hs__nor2b_1
x__2__ clk __7__ VGND VNB VPB VPWR comp_prev sky130_fd_sc_hs__dfxtp_1

* Tieoffs

.ends
