v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 3010 -1490 3010 -1480 {
lab=GND}
N 3010 -1570 3010 -1550 {
lab=vp}
N 2930 -1490 2930 -1480 {
lab=GND}
N 2930 -1570 2930 -1550 {
lab=vss}
N 1170 -720 1190 -720 {
lab=vx}
N 1030 -720 1110 -720 {
lab=inp}
N 1090 -590 1110 -590 {
lab=inp}
N 1090 -720 1090 -590 {
lab=inp}
N 1170 -590 1180 -590 {
lab=vx}
N 1180 -590 1190 -590 {
lab=vx}
N 1190 -720 1190 -590 {
lab=vx}
N 1140 -610 1140 -590 {
lab=vx}
N 1140 -610 1180 -610 {
lab=vx}
N 1180 -610 1180 -590 {
lab=vx}
N 1140 -550 1140 -520 {
lab=reset}
N 1140 -460 1140 -440 {
lab=GND}
N 930 -720 1030 -720 {
lab=inp}
N 820 -800 850 -800 {
lab=vdd}
N 820 -760 850 -760 {
lab=vx}
N 820 -740 900 -740 {
lab=vp}
N 820 -720 840 -720 {
lab=inp}
N 820 -700 900 -700 {
lab=GND}
N 900 -700 900 -680 {
lab=GND}
N 840 -720 930 -720 {
lab=inp}
N 900 -740 920 -740 {
lab=vp}
N 950 -780 950 -760 {
lab=GND}
N 820 -780 880 -780 {
lab=#net1}
N 940 -780 950 -780 {
lab=GND}
N 2080 -680 2080 -640 {
lab=GND}
N 2050 -800 2100 -800 {
lab=inp}
N 2050 -740 2100 -740 {
lab=inn}
N 2050 -720 2100 -720 {
lab=outn}
N 2050 -780 2080 -780 {
lab=ck}
N 2050 -760 2080 -760 {
lab=outp}
N 2050 -820 2100 -820 {
lab=vdd}
N 2050 -680 2080 -680 {
lab=GND}
N 2130 -700 2130 -680 {
lab=#net2}
N 2130 -620 2130 -600 {
lab=GND}
N 2050 -700 2130 -700 {
lab=#net2}
N 2920 -1680 2920 -1660 {
lab=GND}
N 2920 -1790 2920 -1740 {
lab=ck}
N 3110 -1690 3110 -1670 {
lab=GND}
N 3110 -1800 3110 -1750 {
lab=inn}
N 2540 -1530 2540 -1510 {
lab=in+}
N 2540 -1450 2540 -1430 {
lab=GND}
N 2540 -1540 2540 -1530 {
lab=in+}
N 2540 -1550 2540 -1540 {
lab=in+}
N 2540 -1620 2540 -1610 {
lab=in+}
N 2540 -1610 2540 -1550 {
lab=in+}
N 1190 -730 1190 -720 {
lab=vx}
N 1350 -750 1350 -730 {
lab=GND}
N 1190 -810 1190 -730 {
lab=vx}
N 1260 -810 1350 -810 {
lab=#net3}
N 1190 -810 1200 -810 {
lab=vx}
N -330 -2250 -330 -2230 {
lab=#net4}
N -330 -2250 -150 -2250 {
lab=#net4}
N -150 -2250 -150 -2230 {
lab=#net4}
N -390 -2200 -370 -2200 {
lab=in+}
N -110 -2200 -90 -2200 {
lab=n5}
N -150 -2170 -150 -2120 {
lab=#net5}
N -330 -2170 -330 -2040 {
lab=#net6}
N -150 -2070 140 -2070 {
lab=#net5}
N -150 -2120 -150 -2070 {
lab=#net5}
N 310 -2090 310 -2040 {
lab=#net6}
N 180 -2280 260 -2280 {
lab=#net7}
N 260 -2280 270 -2280 {
lab=#net7}
N 140 -2090 140 -2070 {
lab=#net5}
N 180 -2120 270 -2120 {
lab=#net8}
N 180 -1980 270 -1980 {
lab=#net9}
N 140 -2070 140 -2010 {
lab=#net5}
N -330 -2040 310 -2040 {
lab=#net6}
N 310 -2040 310 -2010 {
lab=#net6}
N 140 -1950 140 -1930 {
lab=GND}
N 140 -1830 310 -1830 {
lab=GND}
N 310 -1950 310 -1930 {
lab=GND}
N 230 -1830 230 -1810 {
lab=GND}
N 120 -1980 140 -1980 {
lab=GND}
N 120 -1980 120 -1930 {
lab=GND}
N 120 -1830 140 -1830 {
lab=GND}
N 310 -1980 330 -1980 {
lab=GND}
N 330 -1980 330 -1930 {
lab=GND}
N 310 -1830 330 -1830 {
lab=GND}
N 100 -2120 140 -2120 {
lab=GND}
N 100 -2120 100 -1930 {
lab=GND}
N 100 -1830 120 -1830 {
lab=GND}
N 310 -2120 350 -2120 {
lab=GND}
N 350 -2120 350 -1930 {
lab=GND}
N 330 -1830 350 -1830 {
lab=GND}
N 220 -2120 220 -2060 {
lab=#net8}
N 30 -2060 220 -2060 {
lab=#net8}
N 30 -2060 30 -1880 {
lab=#net8}
N 200 -1980 200 -1890 {
lab=#net9}
N 70 -1790 200 -1790 {
lab=#net9}
N -550 -1870 -550 -1850 {
lab=#net9}
N -550 -1790 -550 -1750 {
lab=#net10}
N -550 -1690 -550 -1670 {
lab=GND}
N -550 -1930 -480 -1930 {
lab=#net8}
N -480 -1930 -480 -1820 {
lab=#net8}
N -510 -1820 30 -1820 {
lab=#net8}
N 30 -1880 30 -1820 {
lab=#net8}
N -550 -1860 -490 -1860 {
lab=#net9}
N -490 -1860 -490 -1720 {
lab=#net9}
N -510 -1720 -490 -1720 {
lab=#net9}
N -490 -1720 70 -1720 {
lab=#net9}
N -580 -1820 -550 -1820 {
lab=GND}
N -580 -1820 -580 -1680 {
lab=GND}
N -580 -1680 -550 -1680 {
lab=GND}
N -570 -1720 -550 -1720 {
lab=GND}
N -570 -1720 -570 -1680 {
lab=GND}
N -550 -2230 -550 -1930 {
lab=#net8}
N -360 -2370 -280 -2370 {
lab=#net11}
N -400 -2340 -400 -2320 {
lab=#net11}
N -400 -2260 -400 -2240 {
lab=GND}
N -550 -2340 -550 -2230 {
lab=#net8}
N -510 -2370 -510 -2330 {
lab=#net11}
N -320 -2370 -320 -2330 {
lab=#net11}
N -400 -2330 -320 -2330 {
lab=#net11}
N -510 -2330 -400 -2330 {
lab=#net11}
N -550 -2430 -550 -2400 {
lab=vdd3v3}
N -550 -2430 -240 -2430 {
lab=vdd3v3}
N -240 -2430 -240 -2400 {
lab=vdd3v3}
N -400 -2430 -400 -2400 {
lab=vdd3v3}
N -400 -2470 -400 -2430 {
lab=vdd3v3}
N -400 -2470 -360 -2470 {
lab=vdd3v3}
N -300 -2470 -280 -2470 {
lab=GND}
N -280 -2470 -270 -2470 {
lab=GND}
N -420 -2370 -400 -2370 {
lab=vdd3v3}
N -420 -2430 -420 -2370 {
lab=vdd3v3}
N -570 -2370 -550 -2370 {
lab=vdd3v3}
N -570 -2430 -570 -2370 {
lab=vdd3v3}
N -570 -2430 -550 -2430 {
lab=vdd3v3}
N -240 -2370 -220 -2370 {
lab=vdd3v3}
N -220 -2430 -220 -2370 {
lab=vdd3v3}
N -240 -2430 -220 -2430 {
lab=vdd3v3}
N -330 -2200 -290 -2200 {
lab=vdd3v3}
N -290 -2430 -290 -2200 {
lab=vdd3v3}
N -170 -2430 -170 -2200 {
lab=vdd3v3}
N -220 -2430 -170 -2430 {
lab=vdd3v3}
N 180 -2370 260 -2370 {
lab=#net12}
N 260 -2370 270 -2370 {
lab=#net12}
N 140 -2430 140 -2400 {
lab=vdd3v3}
N 140 -2430 310 -2430 {
lab=vdd3v3}
N 310 -2430 310 -2400 {
lab=vdd3v3}
N -170 -2430 140 -2430 {
lab=vdd3v3}
N 140 -2340 140 -2310 {
lab=#net13}
N 310 -2340 310 -2310 {
lab=#net14}
N 140 -2250 140 -2240 {
lab=#net12}
N 220 -2370 220 -2250 {
lab=#net12}
N 140 -2240 220 -2240 {
lab=#net12}
N 220 -2250 220 -2240 {
lab=#net12}
N 140 -2240 140 -2230 {
lab=#net12}
N 140 -2170 140 -2150 {
lab=#net7}
N 130 -2370 140 -2370 {
lab=vdd3v3}
N 130 -2430 130 -2370 {
lab=vdd3v3}
N 310 -2370 320 -2370 {
lab=vdd3v3}
N 320 -2430 320 -2370 {
lab=vdd3v3}
N 310 -2430 320 -2430 {
lab=vdd3v3}
N 120 -2280 140 -2280 {
lab=vdd3v3}
N 120 -2430 120 -2280 {
lab=vdd3v3}
N 310 -2280 330 -2280 {
lab=vdd3v3}
N 330 -2430 330 -2280 {
lab=vdd3v3}
N 320 -2430 330 -2430 {
lab=vdd3v3}
N -240 -2260 -240 -2250 {
lab=#net4}
N -240 -2340 -240 -2320 {
lab=#net4}
N 70 -1790 70 -1720 {
lab=#net9}
N 200 -1890 200 -1790 {
lab=#net9}
N 100 -1930 100 -1830 {
lab=GND}
N 120 -1930 120 -1830 {
lab=GND}
N 330 -1930 330 -1830 {
lab=GND}
N 350 -1930 350 -1830 {
lab=GND}
N 140 -1930 140 -1910 {
lab=GND}
N 140 -1850 140 -1830 {
lab=GND}
N -170 -2200 -150 -2200 {
lab=vdd3v3}
N 240 -2280 240 -2160 {
lab=#net7}
N 140 -2160 240 -2160 {
lab=#net7}
N 310 -1930 310 -1910 {
lab=GND}
N 310 -1850 310 -1830 {
lab=GND}
N 310 -2250 310 -2240 {
lab=#net15}
N 310 -2180 310 -2150 {
lab=#net15}
N 310 -2170 420 -2170 {
lab=#net15}
N 640 -1860 640 -1840 {
lab=GND}
N 640 -2000 640 -1950 {
lab=n5}
N 640 -2090 640 -2060 {
lab=vout_s1}
N 640 -2090 740 -2090 {
lab=vout_s1}
N 640 -1890 640 -1860 {
lab=GND}
N 740 -2090 840 -2090 {
lab=vout_s1}
N 580 -1970 640 -1970 {
lab=n5}
N 640 -2160 640 -2090 {
lab=vout_s1}
N 630 -2430 640 -2430 {
lab=vdd3v3}
N 640 -2430 640 -2220 {
lab=vdd3v3}
N 640 -2190 670 -2190 {
lab=vdd3v3}
N 670 -2250 670 -2190 {
lab=vdd3v3}
N 640 -2250 670 -2250 {
lab=vdd3v3}
N 540 -2190 600 -2190 {
lab=n1}
N 330 -2430 630 -2430 {
lab=vdd3v3}
N -240 -2320 -240 -2260 {
lab=#net4}
N 310 -2240 310 -2180 {
lab=#net15}
N 140 -1910 140 -1850 {
lab=GND}
N 310 -1910 310 -1850 {
lab=GND}
N 420 -2190 420 -2170 {
lab=#net15}
N 420 -2190 470 -2190 {
lab=#net15}
N 600 -2090 640 -2090 {
lab=vout_s1}
N 1110 -1750 1110 -1730 {
lab=#net16}
N 1110 -1750 1290 -1750 {
lab=#net16}
N 1290 -1750 1290 -1730 {
lab=#net16}
N 1050 -1700 1070 -1700 {
lab=in+}
N 1330 -1700 1350 -1700 {
lab=nx}
N 1290 -1670 1290 -1620 {
lab=#net17}
N 1110 -1670 1110 -1540 {
lab=#net18}
N 1290 -1570 1580 -1570 {
lab=#net17}
N 1290 -1620 1290 -1570 {
lab=#net17}
N 1750 -1590 1750 -1540 {
lab=#net18}
N 1620 -1780 1700 -1780 {
lab=#net19}
N 1700 -1780 1710 -1780 {
lab=#net19}
N 1580 -1590 1580 -1570 {
lab=#net17}
N 1620 -1620 1710 -1620 {
lab=#net20}
N 1620 -1480 1710 -1480 {
lab=#net21}
N 1580 -1570 1580 -1510 {
lab=#net17}
N 1110 -1540 1750 -1540 {
lab=#net18}
N 1750 -1540 1750 -1510 {
lab=#net18}
N 1580 -1450 1580 -1430 {
lab=GND}
N 1580 -1330 1750 -1330 {
lab=GND}
N 1750 -1450 1750 -1430 {
lab=GND}
N 1670 -1330 1670 -1310 {
lab=GND}
N 1560 -1480 1580 -1480 {
lab=GND}
N 1560 -1480 1560 -1430 {
lab=GND}
N 1560 -1330 1580 -1330 {
lab=GND}
N 1750 -1480 1770 -1480 {
lab=GND}
N 1770 -1480 1770 -1430 {
lab=GND}
N 1750 -1330 1770 -1330 {
lab=GND}
N 1540 -1620 1580 -1620 {
lab=GND}
N 1540 -1620 1540 -1430 {
lab=GND}
N 1540 -1330 1560 -1330 {
lab=GND}
N 1750 -1620 1790 -1620 {
lab=GND}
N 1790 -1620 1790 -1430 {
lab=GND}
N 1770 -1330 1790 -1330 {
lab=GND}
N 1660 -1620 1660 -1560 {
lab=#net20}
N 1470 -1560 1660 -1560 {
lab=#net20}
N 1470 -1560 1470 -1380 {
lab=#net20}
N 1640 -1480 1640 -1390 {
lab=#net21}
N 1510 -1290 1640 -1290 {
lab=#net21}
N 890 -1370 890 -1350 {
lab=#net21}
N 890 -1290 890 -1250 {
lab=#net22}
N 890 -1190 890 -1170 {
lab=GND}
N 890 -1430 960 -1430 {
lab=#net20}
N 960 -1430 960 -1320 {
lab=#net20}
N 930 -1320 1470 -1320 {
lab=#net20}
N 1470 -1380 1470 -1320 {
lab=#net20}
N 890 -1360 950 -1360 {
lab=#net21}
N 950 -1360 950 -1220 {
lab=#net21}
N 930 -1220 950 -1220 {
lab=#net21}
N 950 -1220 1510 -1220 {
lab=#net21}
N 860 -1320 890 -1320 {
lab=GND}
N 860 -1320 860 -1180 {
lab=GND}
N 860 -1180 890 -1180 {
lab=GND}
N 870 -1220 890 -1220 {
lab=GND}
N 870 -1220 870 -1180 {
lab=GND}
N 890 -1730 890 -1430 {
lab=#net20}
N 1080 -1870 1160 -1870 {
lab=#net23}
N 1040 -1840 1040 -1820 {
lab=#net23}
N 1040 -1760 1040 -1740 {
lab=GND}
N 890 -1840 890 -1730 {
lab=#net20}
N 930 -1870 930 -1830 {
lab=#net23}
N 1120 -1870 1120 -1830 {
lab=#net23}
N 1040 -1830 1120 -1830 {
lab=#net23}
N 930 -1830 1040 -1830 {
lab=#net23}
N 890 -1930 890 -1900 {
lab=#net24}
N 890 -1930 1200 -1930 {
lab=#net24}
N 1200 -1930 1200 -1900 {
lab=#net24}
N 1040 -1930 1040 -1900 {
lab=#net24}
N 1020 -1870 1040 -1870 {
lab=#net24}
N 1020 -1930 1020 -1870 {
lab=#net24}
N 870 -1870 890 -1870 {
lab=#net24}
N 870 -1930 870 -1870 {
lab=#net24}
N 870 -1930 890 -1930 {
lab=#net24}
N 1200 -1870 1220 -1870 {
lab=#net24}
N 1220 -1930 1220 -1870 {
lab=#net24}
N 1200 -1930 1220 -1930 {
lab=#net24}
N 1110 -1700 1150 -1700 {
lab=#net24}
N 1150 -1930 1150 -1700 {
lab=#net24}
N 1270 -1930 1270 -1700 {
lab=#net24}
N 1220 -1930 1270 -1930 {
lab=#net24}
N 1620 -1870 1700 -1870 {
lab=#net25}
N 1700 -1870 1710 -1870 {
lab=#net25}
N 1580 -1930 1580 -1900 {
lab=#net24}
N 1580 -1930 1750 -1930 {
lab=#net24}
N 1750 -1930 1750 -1900 {
lab=#net24}
N 1270 -1930 1580 -1930 {
lab=#net24}
N 1580 -1840 1580 -1810 {
lab=#net26}
N 1750 -1840 1750 -1810 {
lab=#net27}
N 1580 -1750 1580 -1740 {
lab=#net25}
N 1660 -1870 1660 -1750 {
lab=#net25}
N 1580 -1740 1660 -1740 {
lab=#net25}
N 1660 -1750 1660 -1740 {
lab=#net25}
N 1580 -1740 1580 -1730 {
lab=#net25}
N 1580 -1670 1580 -1650 {
lab=#net19}
N 1570 -1870 1580 -1870 {
lab=#net24}
N 1570 -1930 1570 -1870 {
lab=#net24}
N 1750 -1870 1760 -1870 {
lab=#net24}
N 1760 -1930 1760 -1870 {
lab=#net24}
N 1750 -1930 1760 -1930 {
lab=#net24}
N 1560 -1780 1580 -1780 {
lab=#net24}
N 1560 -1930 1560 -1780 {
lab=#net24}
N 1750 -1780 1770 -1780 {
lab=#net24}
N 1770 -1930 1770 -1780 {
lab=#net24}
N 1760 -1930 1770 -1930 {
lab=#net24}
N 1200 -1760 1200 -1750 {
lab=#net16}
N 1200 -1840 1200 -1820 {
lab=#net16}
N 1510 -1290 1510 -1220 {
lab=#net21}
N 1640 -1390 1640 -1290 {
lab=#net21}
N 1540 -1430 1540 -1330 {
lab=GND}
N 1560 -1430 1560 -1330 {
lab=GND}
N 1770 -1430 1770 -1330 {
lab=GND}
N 1790 -1430 1790 -1330 {
lab=GND}
N 1580 -1430 1580 -1410 {
lab=GND}
N 1580 -1350 1580 -1330 {
lab=GND}
N 1270 -1700 1290 -1700 {
lab=#net24}
N 1680 -1780 1680 -1660 {
lab=#net19}
N 1580 -1660 1680 -1660 {
lab=#net19}
N 1750 -1430 1750 -1410 {
lab=GND}
N 1750 -1350 1750 -1330 {
lab=GND}
N 1750 -1750 1750 -1740 {
lab=#net28}
N 1750 -1680 1750 -1650 {
lab=#net28}
N 1750 -1670 1860 -1670 {
lab=#net28}
N 2080 -1360 2080 -1340 {
lab=GND}
N 2080 -1500 2080 -1450 {
lab=nx}
N 2080 -1590 2080 -1560 {
lab=#net29}
N 2080 -1590 2180 -1590 {
lab=#net29}
N 2080 -1390 2080 -1360 {
lab=GND}
N 2020 -1470 2080 -1470 {
lab=nx}
N 2080 -1660 2080 -1590 {
lab=#net29}
N 2070 -1930 2080 -1930 {
lab=#net24}
N 2080 -1930 2080 -1720 {
lab=#net24}
N 2080 -1690 2110 -1690 {
lab=#net24}
N 2110 -1750 2110 -1690 {
lab=#net24}
N 2080 -1750 2110 -1750 {
lab=#net24}
N 1980 -1690 2040 -1690 {
lab=n11}
N 1770 -1930 2070 -1930 {
lab=#net24}
N 1200 -1820 1200 -1760 {
lab=#net16}
N 1750 -1740 1750 -1680 {
lab=#net28}
N 1580 -1410 1580 -1350 {
lab=GND}
N 1750 -1410 1750 -1350 {
lab=GND}
N 1860 -1690 1860 -1670 {
lab=#net28}
N 1860 -1690 1910 -1690 {
lab=#net28}
N 840 -2090 840 -1980 {
lab=vout_s1}
N 1000 -1980 1000 -1930 {
lab=#net24}
N 840 -1980 870 -1980 {
lab=vout_s1}
N 930 -1980 1000 -1980 {
lab=#net24}
N 890 -1170 890 -1150 {
lab=GND}
N 1970 -1600 1990 -1600 {
lab=#net30}
N 1890 -1600 1910 -1600 {
lab=#net28}
N 2050 -1600 2080 -1600 {
lab=#net29}
N 1890 -1690 1890 -1600 {
lab=#net28}
N 2240 -1590 2290 -1590 {
lab=vdd}
N 2150 -1590 2150 -1500 {
lab=#net29}
N 2150 -1440 2150 -1360 {
lab=GND}
N 510 -2090 540 -2090 {
lab=#net31}
N 430 -2090 450 -2090 {
lab=#net15}
N 420 -2090 430 -2090 {
lab=#net15}
N 420 -2170 420 -2090 {
lab=#net15}
N 530 -2190 540 -2190 {
lab=n1}
N 1970 -1690 1980 -1690 {
lab=n11}
N 730 -1930 730 -1850 {
lab=GND}
N 730 -2090 730 -1990 {
lab=vout_s1}
C {devices/code_shown.sym} 2760 -1160 0 0 {name=s2 only_toplevel=false value="

.model switch2 sw(Ron=1n Vt=0.9 Roff=10G)
.option method = Gear
*.param Wref= 0.36
.param a0=0
.param a1=0
.param a2=1.8
.param a3=0
.param a4=1.8
*.ic v(inp)=0.2
*.ic v(vx)=0


.control
set color0=white
save all

tran 10u 260u
plot inp inn outp outn
plot inp_neg inn outp_neg outn_neg
let i_1v8 = i(v4)
let i_3v3 = i(v1)
let i_2v4 = i(v5)
let i_g1 = i(v6)
let i_miller1= i(v10)
let i_g2 = i(v11)
let i_miller2= i(v12)
plot i_1v8 i_3v3
plot v(vdd)
plot vdd3v3
plot i_1v8
plot i_3v3
plot i_g1
plot i_miller1
plot i_g2
plot i_miller2
plot n1 
plot n11
*show all
.endc
.end
"
}
C {devices/code.sym} 2670 -1550 0 0 {name=TT_MODELS1
only_toplevel=true
format="tcleval(@value )"
value=".lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice
"
spice_ignore=false
place=header}
C {devices/vsource.sym} 3010 -1520 0 0 {name=V9 value=0.2}
C {devices/gnd.sym} 3010 -1480 0 1 {name=l5 lab=GND}
C {devices/vsource.sym} 2930 -1520 0 0 {name=V7 value=0}
C {devices/gnd.sym} 2930 -1480 0 1 {name=l53 lab=GND}
C {devices/lab_pin.sym} 2930 -1570 0 0 {name=l54 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 3010 -1570 2 0 {name=l59 sig_type=std_logic lab=vp}
C {devices/capa.sym} 1140 -720 1 0 {name=C1
m=1
value=20p
footprint=1206
device="ceramic capacitor"}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 1140 -570 3 0 {name=M32
L=0.15
W=10
nf=1 
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/vsource.sym} 1140 -490 0 0 {name=V22 value="PULSE(0 1.8 0 10p 10p 40n 256.04u)"}
C {devices/gnd.sym} 1140 -440 0 0 {name=l81 lab=GND}
C {devices/lab_pin.sym} 850 -800 2 0 {name=l82 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1140 -530 0 0 {name=l83 sig_type=std_logic lab=reset}
C {devices/lab_pin.sym} 850 -760 2 0 {name=l84 sig_type=std_logic lab=vx}
C {devices/gnd.sym} 900 -680 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} 990 -720 1 0 {name=l86 sig_type=std_logic lab=inp}
C {devices/isource.sym} 910 -780 3 0 {name=I1 value=20u}
C {devices/gnd.sym} 950 -760 0 0 {name=l87 lab=GND}
C {design/single_slope/opamp_singleslope_wcapnew.sym} 670 -750 0 0 {name=x3}
C {devices/lab_pin.sym} 920 -740 0 1 {name=l88 sig_type=std_logic lab=vp}
C {devices/gnd.sym} 2080 -640 0 0 {name=l76 lab=GND}
C {devices/lab_pin.sym} 2100 -820 0 1 {name=l79 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2080 -780 0 1 {name=l107 sig_type=std_logic lab=ck}
C {devices/lab_pin.sym} 2100 -800 0 1 {name=l108 sig_type=std_logic lab=inp}
C {devices/lab_pin.sym} 2100 -740 0 1 {name=l109 sig_type=std_logic lab=inn}
C {devices/lab_pin.sym} 2080 -760 0 1 {name=l110 sig_type=std_logic lab=outp}
C {devices/lab_pin.sym} 2100 -720 0 1 {name=l111 sig_type=std_logic lab=outn}
C {devices/isource.sym} 2130 -650 0 0 {name=I0 value=10u}
C {devices/gnd.sym} 2130 -600 0 0 {name=l112 lab=GND}
C {design/single_slope/comparator_ss_h.sym} 1900 -750 0 0 {name=x7}
C {devices/vsource.sym} 2920 -1710 0 0 {name=V8 value="PULSE(0 1.8 0 10p 10p .5u 1u)"
}
C {devices/gnd.sym} 2920 -1660 0 0 {name=l123 lab=GND}
C {devices/lab_pin.sym} 2920 -1790 0 0 {name=l124 sig_type=std_logic lab=ck}
C {devices/vsource.sym} 3110 -1720 0 0 {name=V23 value=1}
C {devices/gnd.sym} 3110 -1670 0 0 {name=l125 lab=GND}
C {devices/lab_pin.sym} 3110 -1800 0 0 {name=l126 sig_type=std_logic lab=inn}
C {devices/vsource.sym} 2540 -1480 0 0 {name=V3 value=1.2}
C {devices/gnd.sym} 2540 -1430 0 0 {name=l4 lab=GND}
C {devices/lab_pin.sym} 2540 -1620 2 0 {name=l24 sig_type=std_logic lab=in+}
C {devices/vsource.sym} 1350 -780 2 0 {name=V2 value=1}
C {devices/gnd.sym} 1350 -730 0 0 {name=l1 lab=GND}
C {devices/res.sym} 1230 -810 1 0 {name=R1
value=12.7Meg
footprint=1206
device=resistor
m=1}
C {devices/lab_pin.sym} 1190 -810 1 0 {name=l6 sig_type=std_logic lab=vx}
C {devices/lab_pin.sym} -390 -2200 0 0 {name=l2 sig_type=std_logic lab=in+}
C {devices/gnd.sym} 230 -1810 0 0 {name=l7 lab=GND}
C {devices/res.sym} -550 -1900 0 0 {name=R2
value=15k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} -550 -1670 0 0 {name=l27 lab=GND}
C {devices/isource.sym} -400 -2290 0 0 {name=I5 value=15u}
C {devices/gnd.sym} -400 -2240 0 0 {name=l121 lab=GND}
C {devices/vsource.sym} -330 -2470 3 0 {name=V1 value=3.3}
C {devices/gnd.sym} -270 -2470 0 0 {name=l122 lab=GND}
C {devices/res.sym} 140 -2200 0 0 {name=R4
value=10k
footprint=1206
device=resistor
m=1}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} -530 -1820 0 1 {name=M42
L=0.5
W=11
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} -530 -1720 0 1 {name=M43
L=0.5
W=11
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 160 -2120 0 1 {name=M44
L=0.5
W=24
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 290 -2120 0 0 {name=M45
L=0.5
W=24
nf=4 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 160 -1980 0 1 {name=M46
L=0.5
W=48
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 290 -1980 0 0 {name=M47
L=0.5
W=48
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} -530 -2370 0 1 {name=M48
L=0.5
W=12
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} -380 -2370 0 1 {name=M49
L=0.5
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} -260 -2370 0 0 {name=M50
L=0.5
W=12
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} -350 -2200 0 0 {name=M51
L=0.5
W=8
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} -130 -2200 0 1 {name=M52
L=0.5
W=8
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 160 -2370 0 1 {name=M53
L=0.5
W=18
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 160 -2280 0 1 {name=M54
L=0.5
W=18
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 290 -2370 0 0 {name=M55
L=0.5
W=18
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 290 -2280 0 0 {name=M56
L=0.5
W=18
nf=2
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 640 -1840 0 0 {name=l135 lab=GND}
C {devices/res.sym} 640 -2030 0 0 {name=R5
value=120k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 640 -1920 0 0 {name=R6
value=120k
footprint=1206
device=resistor
m=1}
C {devices/lab_pin.sym} 580 -1970 0 0 {name=l136 sig_type=std_logic lab=n5}
C {devices/lab_pin.sym} 840 -2090 0 1 {name=l137 sig_type=std_logic lab=vout_s1}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 620 -2190 0 0 {name=M57
L=0.5
W=9
nf=1
mult=30
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 540 -2190 1 1 {name=l138 sig_type=std_logic lab=n1}
C {devices/lab_pin.sym} 640 -2430 0 1 {name=l139 sig_type=std_logic lab=vdd3v3}
C {devices/lab_pin.sym} -90 -2200 0 1 {name=l140 sig_type=std_logic lab=n5}
C {devices/lab_pin.sym} 1050 -1700 0 0 {name=l141 sig_type=std_logic lab=in+}
C {devices/gnd.sym} 1670 -1310 0 0 {name=l142 lab=GND}
C {devices/res.sym} 890 -1400 0 0 {name=R8
value=15k
footprint=1206
device=resistor
m=1}
C {devices/isource.sym} 1040 -1790 0 0 {name=I6 value=15u}
C {devices/gnd.sym} 1040 -1740 0 0 {name=l143 lab=GND}
C {devices/res.sym} 1580 -1700 0 0 {name=R9
value=10k
footprint=1206
device=resistor
m=1}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 910 -1320 0 1 {name=M58
L=0.5
W=11
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 910 -1220 0 1 {name=M59
L=0.5
W=11
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 1600 -1620 0 1 {name=M60
L=0.5
W=12
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 1730 -1620 0 0 {name=M61
L=0.5
W=12
nf=4 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 1600 -1480 0 1 {name=M62
L=0.5
W=24
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 1730 -1480 0 0 {name=M63
L=0.5
W=24
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 910 -1870 0 1 {name=M64
L=0.5
W=12
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 1060 -1870 0 1 {name=M65
L=0.5
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 1180 -1870 0 0 {name=M66
L=0.5
W=12
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 1090 -1700 0 0 {name=M67
L=0.5
W=8
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 1310 -1700 0 1 {name=M68
L=0.5
W=8
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 1600 -1870 0 1 {name=M69
L=0.5
W=9
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 1600 -1780 0 1 {name=M70
L=0.5
W=9
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 1730 -1870 0 0 {name=M71
L=0.5
W=9
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 1730 -1780 0 0 {name=M72
L=0.5
W=9
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/gnd.sym} 2080 -1340 0 0 {name=l144 lab=GND}
C {devices/res.sym} 2080 -1530 0 0 {name=R10
value=60k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 2080 -1420 0 0 {name=R11
value=120k
footprint=1206
device=resistor
m=1}
C {devices/lab_pin.sym} 2020 -1470 0 0 {name=l145 sig_type=std_logic lab=nx}
C {pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_g5v0d10v5.sym} 2060 -1690 0 0 {name=M73
L=0.5
W=9
nf=1
mult=30
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 1980 -1690 1 1 {name=l147 sig_type=std_logic lab=n11}
C {devices/lab_pin.sym} 1350 -1700 0 1 {name=l148 sig_type=std_logic lab=nx}
C {devices/gnd.sym} 890 -1150 0 0 {name=l157 lab=GND}
C {devices/capa.sym} 2020 -1600 3 0 {name=C5
m=1
value=8p
footprint=1206
device="ceramic capacitor"}
C {devices/lab_pin.sym} 2290 -1590 0 1 {name=l158 sig_type=std_logic lab=vdd}
C {devices/vsource.sym} 2210 -1590 1 0 {name=V4 value=0}
C {devices/capa.sym} 2150 -1470 0 0 {name=C6
m=1
value=50p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2150 -1360 0 0 {name=l146 lab=GND}
C {devices/vsource.sym} 900 -1980 1 0 {name=V5 value=0}
C {devices/capa.sym} 570 -2090 1 0 {name=C3
m=1
value=10p
footprint=1206
device="ceramic capacitor"}
C {devices/vsource.sym} 480 -2090 1 0 {name=V10 value=0}
C {devices/vsource.sym} 500 -2190 1 0 {name=V6 value=0}
C {devices/vsource.sym} 1940 -1690 1 0 {name=V11 value=0}
C {devices/vsource.sym} 1940 -1600 1 0 {name=V12 value=0}
C {devices/code_shown.sym} 3490 -1140 0 0 {name=s1 only_toplevel=false value="

.measure tran ipp1 PP i(v1) from=5u to=6u
.measure tran ipp2 PP i(v1) from=20u to=21u
.measure tran ipp3 PP i(v1) from=50u to=51u
.measure tran ipp4 PP i(v1) from=100u to=101u
.measure tran ipp5 PP i(v1) from=170u to=171u
.measure tran ipp6 PP i(v1) from=220u to=221u
.end
"
}
C {devices/capa.sym} 730 -1960 0 0 {name=C2
m=1
value=50p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 730 -1850 0 0 {name=l3 lab=GND}
