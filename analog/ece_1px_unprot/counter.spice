* counter.spice
* File autogenerated by json2spice.py

* Standard Cell Includes
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/and3/sky130_fd_sc_hs__and3_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/and4/sky130_fd_sc_hs__and4_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/and2/sky130_fd_sc_hs__and2_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/a21oi/sky130_fd_sc_hs__a21oi_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nor3/sky130_fd_sc_hs__nor3_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/o21bai/sky130_fd_sc_hs__o21bai_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nor2/sky130_fd_sc_hs__nor2_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/o21a/sky130_fd_sc_hs__o21a_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/dfxtp/sky130_fd_sc_hs__dfxtp_1.spice

* Subcircuit Definition
.subckt counter clk reset count.0 count.1 count.2 count.3 count.4 count.5 count.6 count.7 VGND VNB VPB VPWR

* Standard Cells
x__0__ count.0 count.1 count.2 VGND VNB VPB VPWR __12__ sky130_fd_sc_hs__and3_1
x__1__ count.0 count.1 count.2 count.3 VGND VNB VPB VPWR __13__ sky130_fd_sc_hs__and4_1
x__2__ count.4 __13__ VGND VNB VPB VPWR __14__ sky130_fd_sc_hs__and2_1
x__3__ count.4 count.5 count.6 __13__ VGND VNB VPB VPWR __15__ sky130_fd_sc_hs__and4_1
x__4__ count.5 __14__ count.6 VGND VNB VPB VPWR __16__ sky130_fd_sc_hs__a21oi_1
x__5__ reset __15__ __16__ VGND VNB VPB VPWR __17__ sky130_fd_sc_hs__nor3_1
x__6__ count.7 __15__ reset VGND VNB VPB VPWR __18__ sky130_fd_sc_hs__o21bai_1
x__7__ count.7 __15__ __18__ VGND VNB VPB VPWR __19__ sky130_fd_sc_hs__a21oi_1
x__8__ count.0 reset VGND VNB VPB VPWR __20__ sky130_fd_sc_hs__nor2_1
x__9__ count.0 count.1 reset VGND VNB VPB VPWR __21__ sky130_fd_sc_hs__a21oi_1
x__10__ count.0 count.1 __21__ VGND VNB VPB VPWR __22__ sky130_fd_sc_hs__o21a_1
x__11__ count.0 count.1 count.2 VGND VNB VPB VPWR __23__ sky130_fd_sc_hs__a21oi_1
x__12__ reset __12__ __23__ VGND VNB VPB VPWR __24__ sky130_fd_sc_hs__nor3_1
x__13__ count.3 __12__ VGND VNB VPB VPWR __25__ sky130_fd_sc_hs__nor2_1
x__14__ reset __13__ __25__ VGND VNB VPB VPWR __26__ sky130_fd_sc_hs__nor3_1
x__15__ count.4 __13__ VGND VNB VPB VPWR __27__ sky130_fd_sc_hs__nor2_1
x__16__ reset __14__ __27__ VGND VNB VPB VPWR __28__ sky130_fd_sc_hs__nor3_1
x__17__ count.5 __14__ reset VGND VNB VPB VPWR __29__ sky130_fd_sc_hs__a21oi_1
x__18__ count.5 __14__ __29__ VGND VNB VPB VPWR __30__ sky130_fd_sc_hs__o21a_1
x__19__ clk __17__ VGND VNB VPB VPWR count.6 sky130_fd_sc_hs__dfxtp_1
x__20__ clk __19__ VGND VNB VPB VPWR count.7 sky130_fd_sc_hs__dfxtp_1
x__21__ clk __20__ VGND VNB VPB VPWR count.0 sky130_fd_sc_hs__dfxtp_1
x__22__ clk __22__ VGND VNB VPB VPWR count.1 sky130_fd_sc_hs__dfxtp_1
x__23__ clk __24__ VGND VNB VPB VPWR count.2 sky130_fd_sc_hs__dfxtp_1
x__24__ clk __26__ VGND VNB VPB VPWR count.3 sky130_fd_sc_hs__dfxtp_1
x__25__ clk __28__ VGND VNB VPB VPWR count.4 sky130_fd_sc_hs__dfxtp_1
x__26__ clk __30__ VGND VNB VPB VPWR count.5 sky130_fd_sc_hs__dfxtp_1

* Tieoffs

.ends
