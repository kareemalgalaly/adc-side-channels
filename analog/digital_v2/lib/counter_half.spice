* counter_half.spice
* File autogenerated by json2spice.py

* Standard Cell Includes
*.include cells/nor2b/sky130_fd_sc_hs__nor2b_1.spice
*.include cells/dfxtp/sky130_fd_sc_hs__dfxtp_1.spice
*.include cells/and2/sky130_fd_sc_hs__and2_1.spice
*.include cells/xor2/sky130_fd_sc_hs__xor2_1.spice

** model ---------------------------------------------------
.lib model

.subckt counter_half clk rst en count0 count1 count2 count3 count4 count5 count6 count7 overflow VGND VNB VPB VPWR

abridgea [rst clk] [dreset dclk] atod
abridged [dcount0 dcount1 dcount2 dcount3 dcount4 dcount5 dcount6 dcount7] [count0 count1 count2 count3 count4 count5 count6 count7] dtoa
acounter null dclk dreset [dcount0 dcount1 dcount2 dcount3 dcount4 dcount5 dcount6 dcount7] proc_counter
.model atod adc_bridge(in_low=0.2 in_high=1.6)
.model dtoa dac_bridge(out_low=0 out_high=1.8)
.model proc_counter d_process (process_file="/home/kareem/miniconda3/envs/pykit/bin/python" process_params=["lib/counter.py"])
.ends

.endl model

** synth ---------------------------------------------------
.lib synth

.subckt counter_half clk rst en count.0 count.1 count.2 count.3 count.4 count.5 count.6 count.7 overflow VGND VNB VPB VPWR
x__0__ rst genblk1[6].half_adder.S VGND VNB VPB VPWR __15__ sky130_fd_sc_hs__nor2b_1
x__1__ rst genblk1[7].half_adder.S VGND VNB VPB VPWR __17__ sky130_fd_sc_hs__nor2b_1
x__2__ rst carry.7 VGND VNB VPB VPWR __19__ sky130_fd_sc_hs__nor2b_1
x__3__ rst genblk1[0].half_adder.S VGND VNB VPB VPWR __21__ sky130_fd_sc_hs__nor2b_1
x__4__ rst genblk1[1].half_adder.S VGND VNB VPB VPWR __23__ sky130_fd_sc_hs__nor2b_1
x__5__ rst genblk1[2].half_adder.S VGND VNB VPB VPWR __25__ sky130_fd_sc_hs__nor2b_1
x__6__ rst genblk1[3].half_adder.S VGND VNB VPB VPWR __27__ sky130_fd_sc_hs__nor2b_1
x__7__ rst genblk1[4].half_adder.S VGND VNB VPB VPWR __29__ sky130_fd_sc_hs__nor2b_1
x__8__ rst genblk1[5].half_adder.S VGND VNB VPB VPWR __31__ sky130_fd_sc_hs__nor2b_1
x__9__ clk __15__ VGND VNB VPB VPWR count.6 sky130_fd_sc_hs__dfxtp_1
x__10__ clk __17__ VGND VNB VPB VPWR count.7 sky130_fd_sc_hs__dfxtp_1
x__11__ clk __19__ VGND VNB VPB VPWR overflow sky130_fd_sc_hs__dfxtp_1
x__12__ clk __21__ VGND VNB VPB VPWR count.0 sky130_fd_sc_hs__dfxtp_1
x__13__ clk __23__ VGND VNB VPB VPWR count.1 sky130_fd_sc_hs__dfxtp_1
x__14__ clk __25__ VGND VNB VPB VPWR count.2 sky130_fd_sc_hs__dfxtp_1
x__15__ clk __27__ VGND VNB VPB VPWR count.3 sky130_fd_sc_hs__dfxtp_1
x__16__ clk __29__ VGND VNB VPB VPWR count.4 sky130_fd_sc_hs__dfxtp_1
x__17__ clk __31__ VGND VNB VPB VPWR count.5 sky130_fd_sc_hs__dfxtp_1
x__18__ en count.0 VGND VNB VPB VPWR carry.0 sky130_fd_sc_hs__and2_1
x__19__ en count.0 VGND VNB VPB VPWR genblk1[0].half_adder.S sky130_fd_sc_hs__xor2_1
x__20__ carry.0 count.1 VGND VNB VPB VPWR carry.1 sky130_fd_sc_hs__and2_1
x__21__ carry.0 count.1 VGND VNB VPB VPWR genblk1[1].half_adder.S sky130_fd_sc_hs__xor2_1
x__22__ carry.1 count.2 VGND VNB VPB VPWR carry.2 sky130_fd_sc_hs__and2_1
x__23__ carry.1 count.2 VGND VNB VPB VPWR genblk1[2].half_adder.S sky130_fd_sc_hs__xor2_1
x__24__ carry.2 count.3 VGND VNB VPB VPWR carry.3 sky130_fd_sc_hs__and2_1
x__25__ carry.2 count.3 VGND VNB VPB VPWR genblk1[3].half_adder.S sky130_fd_sc_hs__xor2_1
x__26__ carry.3 count.4 VGND VNB VPB VPWR carry.4 sky130_fd_sc_hs__and2_1
x__27__ carry.3 count.4 VGND VNB VPB VPWR genblk1[4].half_adder.S sky130_fd_sc_hs__xor2_1
x__28__ carry.4 count.5 VGND VNB VPB VPWR carry.5 sky130_fd_sc_hs__and2_1
x__29__ carry.4 count.5 VGND VNB VPB VPWR genblk1[5].half_adder.S sky130_fd_sc_hs__xor2_1
x__30__ carry.5 count.6 VGND VNB VPB VPWR carry.6 sky130_fd_sc_hs__and2_1
x__31__ carry.5 count.6 VGND VNB VPB VPWR genblk1[6].half_adder.S sky130_fd_sc_hs__xor2_1
x__32__ carry.6 count.7 VGND VNB VPB VPWR carry.7 sky130_fd_sc_hs__and2_1
x__33__ carry.6 count.7 VGND VNB VPB VPWR genblk1[7].half_adder.S sky130_fd_sc_hs__xor2_1
.ends

.endl synth
