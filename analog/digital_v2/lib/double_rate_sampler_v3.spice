* double_rate_sampler.spice
* File autogenerated by json2spice.py
* File manually edited by Kareem Ahmad
* inv -> inv

* Standard Cell Includes
.include cells/inv/sky130_fd_sc_hs__inv_1.spice
.include cells/or2/sky130_fd_sc_hs__or2_1.spice
.include cells/nand2b/sky130_fd_sc_hs__nand2b_1.spice
.include cells/nor3b/sky130_fd_sc_hs__nor3b_1.spice
.include cells/a211oi/sky130_fd_sc_hs__a211oi_1.spice
.include cells/mux2i/sky130_fd_sc_hs__mux2i_1.spice
.include cells/nor2/sky130_fd_sc_hs__nor2_1.spice
.include cells/dfxtp/sky130_fd_sc_hs__dfxtp_1.spice
.include cells/nor2b/sky130_fd_sc_hs__nor2b_1.spice

* Subcircuit Definition
.subckt double_rate_sampler clk rst comp compn counter.0 counter.1 counter.2 counter.3 counter.4 counter.5 counter.6 counter.7 count_true.0 count_true.1 count_true.2 count_true.3 count_true.4 count_true.5 count_true.6 count_true.7 count_false.0 count_false.1 count_false.2 count_false.3 count_false.4 count_false.5 count_false.6 count_false.7 VGND VNB VPB VPWR

* Standard Cells
x__0__ count_true.7 VGND VNB VPB VPWR __30__ sky130_fd_sc_hs__inv_1
x__1__ count_true.6 VGND VNB VPB VPWR __31__ sky130_fd_sc_hs__inv_1
x__2__ count_true.5 VGND VNB VPB VPWR __32__ sky130_fd_sc_hs__inv_1
x__3__ count_true.4 VGND VNB VPB VPWR __33__ sky130_fd_sc_hs__inv_1
x__4__ count_true.3 VGND VNB VPB VPWR __34__ sky130_fd_sc_hs__inv_1
x__5__ count_true.2 VGND VNB VPB VPWR __35__ sky130_fd_sc_hs__inv_1
x__6__ count_true.1 VGND VNB VPB VPWR __36__ sky130_fd_sc_hs__inv_1
x__7__ count_true.0 VGND VNB VPB VPWR __37__ sky130_fd_sc_hs__inv_1
x__8__ reset_cycle VGND VNB VPB VPWR set_cycle sky130_fd_sc_hs__inv_1
x__9__ reset_cycle rst VGND VNB VPB VPWR __40__ sky130_fd_sc_hs__or2_1
x__10__ __40__ VGND VNB VPB VPWR __41__ sky130_fd_sc_hs__inv_1
x__11__ reset_cycle wen VGND VNB VPB VPWR __43__ sky130_fd_sc_hs__nand2b_1
x__12__ counter.0 reset_cycle wen VGND VNB VPB VPWR __44__ sky130_fd_sc_hs__nor3b_1
x__13__ __37__ __43__ __44__ rst VGND VNB VPB VPWR __45__ sky130_fd_sc_hs__a211oi_1
x__14__ counter.1 reset_cycle wen VGND VNB VPB VPWR __46__ sky130_fd_sc_hs__nor3b_1
x__15__ __36__ __43__ __46__ rst VGND VNB VPB VPWR __47__ sky130_fd_sc_hs__a211oi_1
x__16__ counter.2 reset_cycle wen VGND VNB VPB VPWR __48__ sky130_fd_sc_hs__nor3b_1
x__17__ __35__ __43__ __48__ rst VGND VNB VPB VPWR __49__ sky130_fd_sc_hs__a211oi_1
x__18__ counter.3 reset_cycle wen VGND VNB VPB VPWR __50__ sky130_fd_sc_hs__nor3b_1
x__19__ __34__ __43__ __50__ rst VGND VNB VPB VPWR __51__ sky130_fd_sc_hs__a211oi_1
x__20__ counter.4 reset_cycle wen VGND VNB VPB VPWR __52__ sky130_fd_sc_hs__nor3b_1
x__21__ __33__ __43__ __52__ rst VGND VNB VPB VPWR __53__ sky130_fd_sc_hs__a211oi_1
x__22__ counter.5 reset_cycle wen VGND VNB VPB VPWR __54__ sky130_fd_sc_hs__nor3b_1
x__23__ __32__ __43__ __54__ rst VGND VNB VPB VPWR __55__ sky130_fd_sc_hs__a211oi_1
x__24__ counter.6 reset_cycle wen VGND VNB VPB VPWR __56__ sky130_fd_sc_hs__nor3b_1
x__25__ __31__ __43__ __56__ rst VGND VNB VPB VPWR __57__ sky130_fd_sc_hs__a211oi_1
x__26__ counter.7 reset_cycle wen VGND VNB VPB VPWR __58__ sky130_fd_sc_hs__nor3b_1
x__27__ __30__ __43__ __58__ rst VGND VNB VPB VPWR __59__ sky130_fd_sc_hs__a211oi_1
x__28__ counter.0 count_false.0 wen VGND VNB VPB VPWR __60__ sky130_fd_sc_hs__mux2i_1
x__29__ __40__ __60__ VGND VNB VPB VPWR __61__ sky130_fd_sc_hs__nor2_1
x__30__ counter.1 count_false.1 wen VGND VNB VPB VPWR __62__ sky130_fd_sc_hs__mux2i_1
x__31__ __40__ __62__ VGND VNB VPB VPWR __63__ sky130_fd_sc_hs__nor2_1
x__32__ counter.2 count_false.2 wen VGND VNB VPB VPWR __64__ sky130_fd_sc_hs__mux2i_1
x__33__ __40__ __64__ VGND VNB VPB VPWR __65__ sky130_fd_sc_hs__nor2_1
x__34__ counter.3 count_false.3 wen VGND VNB VPB VPWR __66__ sky130_fd_sc_hs__mux2i_1
x__35__ __40__ __66__ VGND VNB VPB VPWR __67__ sky130_fd_sc_hs__nor2_1
x__36__ counter.4 count_false.4 wen VGND VNB VPB VPWR __68__ sky130_fd_sc_hs__mux2i_1
x__37__ __40__ __68__ VGND VNB VPB VPWR __69__ sky130_fd_sc_hs__nor2_1
x__38__ counter.5 count_false.5 wen VGND VNB VPB VPWR __70__ sky130_fd_sc_hs__mux2i_1
x__39__ __40__ __70__ VGND VNB VPB VPWR __71__ sky130_fd_sc_hs__nor2_1
x__40__ counter.6 count_false.6 wen VGND VNB VPB VPWR __72__ sky130_fd_sc_hs__mux2i_1
x__41__ __40__ __72__ VGND VNB VPB VPWR __73__ sky130_fd_sc_hs__nor2_1
x__42__ counter.7 count_false.7 wen VGND VNB VPB VPWR __74__ sky130_fd_sc_hs__mux2i_1
x__43__ __40__ __74__ VGND VNB VPB VPWR __75__ sky130_fd_sc_hs__nor2_1
x__44__ clk __41__ VGND VNB VPB VPWR reset_cycle sky130_fd_sc_hs__dfxtp_1
x__45__ clk __45__ VGND VNB VPB VPWR count_true.0 sky130_fd_sc_hs__dfxtp_1
x__46__ clk __47__ VGND VNB VPB VPWR count_true.1 sky130_fd_sc_hs__dfxtp_1
x__47__ clk __49__ VGND VNB VPB VPWR count_true.2 sky130_fd_sc_hs__dfxtp_1
x__48__ clk __51__ VGND VNB VPB VPWR count_true.3 sky130_fd_sc_hs__dfxtp_1
x__49__ clk __53__ VGND VNB VPB VPWR count_true.4 sky130_fd_sc_hs__dfxtp_1
x__50__ clk __55__ VGND VNB VPB VPWR count_true.5 sky130_fd_sc_hs__dfxtp_1
x__51__ clk __57__ VGND VNB VPB VPWR count_true.6 sky130_fd_sc_hs__dfxtp_1
x__52__ clk __59__ VGND VNB VPB VPWR count_true.7 sky130_fd_sc_hs__dfxtp_1
x__53__ clk __61__ VGND VNB VPB VPWR count_false.0 sky130_fd_sc_hs__dfxtp_1
x__54__ clk __63__ VGND VNB VPB VPWR count_false.1 sky130_fd_sc_hs__dfxtp_1
x__55__ clk __65__ VGND VNB VPB VPWR count_false.2 sky130_fd_sc_hs__dfxtp_1
x__56__ clk __67__ VGND VNB VPB VPWR count_false.3 sky130_fd_sc_hs__dfxtp_1
x__57__ clk __69__ VGND VNB VPB VPWR count_false.4 sky130_fd_sc_hs__dfxtp_1
x__58__ clk __71__ VGND VNB VPB VPWR count_false.5 sky130_fd_sc_hs__dfxtp_1
x__59__ clk __73__ VGND VNB VPB VPWR count_false.6 sky130_fd_sc_hs__dfxtp_1
x__60__ clk __75__ VGND VNB VPB VPWR count_false.7 sky130_fd_sc_hs__dfxtp_1
x__61__ pdn.vald compn VGND VNB VPB VPWR wenn sky130_fd_sc_hs__nor2b_1
x__62__ pdn.vald compn set_cycle VGND VNB VPB VPWR __78__ sky130_fd_sc_hs__mux2i_1
x__63__ rst __78__ VGND VNB VPB VPWR __79__ sky130_fd_sc_hs__nor2_1
x__64__ clk __79__ VGND VNB VPB VPWR pdn.vald sky130_fd_sc_hs__dfxtp_1
x__65__ pdp.vald comp VGND VNB VPB VPWR wen sky130_fd_sc_hs__nor2b_1
x__66__ pdp.vald comp set_cycle VGND VNB VPB VPWR __81__ sky130_fd_sc_hs__mux2i_1
x__67__ rst __81__ VGND VNB VPB VPWR __82__ sky130_fd_sc_hs__nor2_1
x__68__ clk __82__ VGND VNB VPB VPWR pdp.vald sky130_fd_sc_hs__dfxtp_1

* Tieoffs

.ends
