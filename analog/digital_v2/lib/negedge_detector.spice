* negedge_detector.spice
* File autogenerated by json2spice.py

* Standard Cell Includes
*.include cells/clkinv/sky130_fd_sc_hs__inv_1.spice
*.include cells/nor2b/sky130_fd_sc_hs__nor2b_1.spice
*.include cells/o21ba/sky130_fd_sc_hs__o21ba_1.spice
*.include cells/dfxtp/sky130_fd_sc_hs__dfxtp_1.spice

** synth ---------------------------------------------------
.lib synth
.subckt negedge_detector clk reset comp enable VGND VNB VPB VPWR

* Standard Cells
x__0__ clk VGND VNB VPB VPWR __6__ sky130_fd_sc_hs__inv_1
x__1__ reset comp VGND VNB VPB VPWR __7__ sky130_fd_sc_hs__nor2b_1
x__2__ sample_hold_registered sample_hold VGND VNB VPB VPWR enable sky130_fd_sc_hs__nor2b_1
x__3__ reset sample_hold VGND VNB VPB VPWR __10__ sky130_fd_sc_hs__nor2b_1
x__4__ sample_hold negedge_sample reset VGND VNB VPB VPWR __12__ sky130_fd_sc_hs__o21ba_1
x__5__ __6__ __7__ VGND VNB VPB VPWR negedge_sample sky130_fd_sc_hs__dfxtp_1
x__6__ clk __12__ VGND VNB VPB VPWR sample_hold sky130_fd_sc_hs__dfxtp_1
x__7__ clk __10__ VGND VNB VPB VPWR sample_hold_registered sky130_fd_sc_hs__dfxtp_1

.ends
.endl synth

** synth hd ------------------------------------------------
.lib synth_hd
.subckt negedge_detector clk reset comp enable VGND VNB VPB VPWR

* Standard Cells
x__0__ clk VGND VNB VPB VPWR __6__ sky130_fd_sc_hd__inv_1
x__1__ reset comp VGND VNB VPB VPWR __7__ sky130_fd_sc_hd__nor2b_1
x__2__ sample_hold_registered sample_hold VGND VNB VPB VPWR enable sky130_fd_sc_hd__nor2b_1
x__3__ reset sample_hold VGND VNB VPB VPWR __10__ sky130_fd_sc_hd__nor2b_1
x__4__ sample_hold negedge_sample reset VGND VNB VPB VPWR __12__ sky130_fd_sc_hd__o21ba_1
x__5__ __6__ __7__ VGND VNB VPB VPWR negedge_sample sky130_fd_sc_hd__dfxtp_1
x__6__ clk __12__ VGND VNB VPB VPWR sample_hold sky130_fd_sc_hd__dfxtp_1
x__7__ clk __10__ VGND VNB VPB VPWR sample_hold_registered sky130_fd_sc_hd__dfxtp_1

.ends
.endl synth_hd
