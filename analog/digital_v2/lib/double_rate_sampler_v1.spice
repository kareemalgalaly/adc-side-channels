* double_rate_sampler.spice
* File autogenerated by json2spice.py

* Standard Cell Includes
.include cells/clkinv/sky130_fd_sc_hs__clkinv_1.spice
.include cells/nor2b/sky130_fd_sc_hs__nor2b_1.spice
.include cells/mux2/sky130_fd_sc_hs__mux2_1.spice
.include cells/nand2b/sky130_fd_sc_hs__nand2b_1.spice
.include cells/or3b/sky130_fd_sc_hs__or3b_1.spice
.include cells/nor4b/sky130_fd_sc_hs__nor4b_1.spice
.include cells/a211oi/sky130_fd_sc_hs__a211oi_1.spice
.include cells/or2/sky130_fd_sc_hs__or2_1.spice
.include cells/nor3b/sky130_fd_sc_hs__nor3b_1.spice
.include cells/and2/sky130_fd_sc_hs__and2_1.spice
.include cells/mux2i/sky130_fd_sc_hs__mux2i_1.spice
.include cells/nor2/sky130_fd_sc_hs__nor2_1.spice
.include cells/edfxtp/sky130_fd_sc_hs__edfxtp_1.spice
.include cells/dfxtp/sky130_fd_sc_hs__dfxtp_1.spice

* Subcircuit Definition
.subckt double_rate_sampler clk rst comp compn counter.0 counter.1 counter.2 counter.3 counter.4 counter.5 counter.6 counter.7 count_true.0 count_true.1 count_true.2 count_true.3 count_true.4 count_true.5 count_true.6 count_true.7 count_false.0 count_false.1 count_false.2 count_false.3 count_false.4 count_false.5 count_false.6 count_false.7 VGND VNB VPB VPWR

* Standard Cells
x__0__ counter.7 VGND VNB VPB VPWR __30__ sky130_fd_sc_hs__clkinv_1
x__1__ counter.6 VGND VNB VPB VPWR __31__ sky130_fd_sc_hs__clkinv_1
x__2__ counter.5 VGND VNB VPB VPWR __32__ sky130_fd_sc_hs__clkinv_1
x__3__ counter.4 VGND VNB VPB VPWR __33__ sky130_fd_sc_hs__clkinv_1
x__4__ counter.3 VGND VNB VPB VPWR __34__ sky130_fd_sc_hs__clkinv_1
x__5__ counter.2 VGND VNB VPB VPWR __35__ sky130_fd_sc_hs__clkinv_1
x__6__ counter.1 VGND VNB VPB VPWR __36__ sky130_fd_sc_hs__clkinv_1
x__7__ counter.0 VGND VNB VPB VPWR __37__ sky130_fd_sc_hs__clkinv_1
x__8__ count_true.7 VGND VNB VPB VPWR __38__ sky130_fd_sc_hs__clkinv_1
x__9__ count_true.6 VGND VNB VPB VPWR __39__ sky130_fd_sc_hs__clkinv_1
x__10__ count_true.5 VGND VNB VPB VPWR __40__ sky130_fd_sc_hs__clkinv_1
x__11__ count_true.4 VGND VNB VPB VPWR __41__ sky130_fd_sc_hs__clkinv_1
x__12__ count_true.3 VGND VNB VPB VPWR __42__ sky130_fd_sc_hs__clkinv_1
x__13__ count_true.2 VGND VNB VPB VPWR __43__ sky130_fd_sc_hs__clkinv_1
x__14__ count_true.1 VGND VNB VPB VPWR __44__ sky130_fd_sc_hs__clkinv_1
x__15__ count_true.0 VGND VNB VPB VPWR __45__ sky130_fd_sc_hs__clkinv_1
x__16__ rst VGND VNB VPB VPWR __46__ sky130_fd_sc_hs__clkinv_1
x__17__ comp_dn compn VGND VNB VPB VPWR wenn sky130_fd_sc_hs__nor2b_1
x__18__ compn comp_dn reset_cycle VGND VNB VPB VPWR __50__ sky130_fd_sc_hs__mux2_1
x__19__ comp_d comp VGND VNB VPB VPWR __52__ sky130_fd_sc_hs__nand2b_1
x__20__ comp_d reset_cycle comp VGND VNB VPB VPWR __53__ sky130_fd_sc_hs__or3b_1
x__21__ comp_d reset_cycle counter.0 comp VGND VNB VPB VPWR __54__ sky130_fd_sc_hs__nor4b_1
x__22__ __45__ __53__ __54__ rst VGND VNB VPB VPWR __55__ sky130_fd_sc_hs__a211oi_1
x__23__ comp_d reset_cycle counter.1 comp VGND VNB VPB VPWR __56__ sky130_fd_sc_hs__nor4b_1
x__24__ __44__ __53__ __56__ rst VGND VNB VPB VPWR __57__ sky130_fd_sc_hs__a211oi_1
x__25__ comp_d reset_cycle counter.2 comp VGND VNB VPB VPWR __58__ sky130_fd_sc_hs__nor4b_1
x__26__ __43__ __53__ __58__ rst VGND VNB VPB VPWR __59__ sky130_fd_sc_hs__a211oi_1
x__27__ comp_d reset_cycle counter.3 comp VGND VNB VPB VPWR __60__ sky130_fd_sc_hs__nor4b_1
x__28__ __42__ __53__ __60__ rst VGND VNB VPB VPWR __61__ sky130_fd_sc_hs__a211oi_1
x__29__ comp_d reset_cycle counter.4 comp VGND VNB VPB VPWR __62__ sky130_fd_sc_hs__nor4b_1
x__30__ __41__ __53__ __62__ rst VGND VNB VPB VPWR __63__ sky130_fd_sc_hs__a211oi_1
x__31__ comp_d reset_cycle counter.5 comp VGND VNB VPB VPWR __64__ sky130_fd_sc_hs__nor4b_1
x__32__ __40__ __53__ __64__ rst VGND VNB VPB VPWR __65__ sky130_fd_sc_hs__a211oi_1
x__33__ comp_d reset_cycle counter.6 comp VGND VNB VPB VPWR __66__ sky130_fd_sc_hs__nor4b_1
x__34__ __39__ __53__ __66__ rst VGND VNB VPB VPWR __67__ sky130_fd_sc_hs__a211oi_1
x__35__ comp_d reset_cycle counter.7 comp VGND VNB VPB VPWR __68__ sky130_fd_sc_hs__nor4b_1
x__36__ __38__ __53__ __68__ rst VGND VNB VPB VPWR __69__ sky130_fd_sc_hs__a211oi_1
x__37__ reset_cycle rst VGND VNB VPB VPWR __70__ sky130_fd_sc_hs__or2_1
x__38__ __70__ VGND VNB VPB VPWR __71__ sky130_fd_sc_hs__clkinv_1
x__39__ comp_d count_false.0 comp VGND VNB VPB VPWR __72__ sky130_fd_sc_hs__nor3b_1
x__40__ __37__ __52__ __70__ __72__ VGND VNB VPB VPWR __73__ sky130_fd_sc_hs__a211oi_1
x__41__ comp_d count_false.1 comp VGND VNB VPB VPWR __74__ sky130_fd_sc_hs__nor3b_1
x__42__ __36__ __52__ __70__ __74__ VGND VNB VPB VPWR __75__ sky130_fd_sc_hs__a211oi_1
x__43__ comp_d count_false.2 comp VGND VNB VPB VPWR __76__ sky130_fd_sc_hs__nor3b_1
x__44__ __35__ __52__ __70__ __76__ VGND VNB VPB VPWR __77__ sky130_fd_sc_hs__a211oi_1
x__45__ comp_d count_false.3 comp VGND VNB VPB VPWR __78__ sky130_fd_sc_hs__nor3b_1
x__46__ __34__ __52__ __70__ __78__ VGND VNB VPB VPWR __79__ sky130_fd_sc_hs__a211oi_1
x__47__ comp_d count_false.4 comp VGND VNB VPB VPWR __80__ sky130_fd_sc_hs__nor3b_1
x__48__ __33__ __52__ __70__ __80__ VGND VNB VPB VPWR __81__ sky130_fd_sc_hs__a211oi_1
x__49__ comp_d count_false.5 comp VGND VNB VPB VPWR __82__ sky130_fd_sc_hs__nor3b_1
x__50__ __32__ __52__ __70__ __82__ VGND VNB VPB VPWR __83__ sky130_fd_sc_hs__a211oi_1
x__51__ comp_d count_false.6 comp VGND VNB VPB VPWR __84__ sky130_fd_sc_hs__nor3b_1
x__52__ __31__ __52__ __70__ __84__ VGND VNB VPB VPWR __85__ sky130_fd_sc_hs__a211oi_1
x__53__ comp_d count_false.7 comp VGND VNB VPB VPWR __86__ sky130_fd_sc_hs__nor3b_1
x__54__ __30__ __52__ __70__ __86__ VGND VNB VPB VPWR __87__ sky130_fd_sc_hs__a211oi_1
x__55__ __46__ __50__ VGND VNB VPB VPWR __88__ sky130_fd_sc_hs__and2_1
x__56__ comp comp_d reset_cycle VGND VNB VPB VPWR __89__ sky130_fd_sc_hs__mux2i_1
x__57__ rst __89__ VGND VNB VPB VPWR __90__ sky130_fd_sc_hs__nor2_1
x__58__ clk __50__ __46__ VGND VNB VPB VPWR comp_dn sky130_fd_sc_hs__edfxtp_1
x__59__ clk __55__ VGND VNB VPB VPWR count_true.0 sky130_fd_sc_hs__dfxtp_1
x__60__ clk __57__ VGND VNB VPB VPWR count_true.1 sky130_fd_sc_hs__dfxtp_1
x__61__ clk __59__ VGND VNB VPB VPWR count_true.2 sky130_fd_sc_hs__dfxtp_1
x__62__ clk __61__ VGND VNB VPB VPWR count_true.3 sky130_fd_sc_hs__dfxtp_1
x__63__ clk __63__ VGND VNB VPB VPWR count_true.4 sky130_fd_sc_hs__dfxtp_1
x__64__ clk __65__ VGND VNB VPB VPWR count_true.5 sky130_fd_sc_hs__dfxtp_1
x__65__ clk __67__ VGND VNB VPB VPWR count_true.6 sky130_fd_sc_hs__dfxtp_1
x__66__ clk __69__ VGND VNB VPB VPWR count_true.7 sky130_fd_sc_hs__dfxtp_1
x__67__ clk __73__ VGND VNB VPB VPWR count_false.0 sky130_fd_sc_hs__dfxtp_1
x__68__ clk __75__ VGND VNB VPB VPWR count_false.1 sky130_fd_sc_hs__dfxtp_1
x__69__ clk __77__ VGND VNB VPB VPWR count_false.2 sky130_fd_sc_hs__dfxtp_1
x__70__ clk __79__ VGND VNB VPB VPWR count_false.3 sky130_fd_sc_hs__dfxtp_1
x__71__ clk __81__ VGND VNB VPB VPWR count_false.4 sky130_fd_sc_hs__dfxtp_1
x__72__ clk __83__ VGND VNB VPB VPWR count_false.5 sky130_fd_sc_hs__dfxtp_1
x__73__ clk __85__ VGND VNB VPB VPWR count_false.6 sky130_fd_sc_hs__dfxtp_1
x__74__ clk __87__ VGND VNB VPB VPWR count_false.7 sky130_fd_sc_hs__dfxtp_1
x__75__ clk __88__ VGND VNB VPB VPWR comp_dn sky130_fd_sc_hs__dfxtp_1
x__76__ clk __90__ VGND VNB VPB VPWR comp_d sky130_fd_sc_hs__dfxtp_1
x__77__ clk __71__ VGND VNB VPB VPWR reset_cycle sky130_fd_sc_hs__dfxtp_1

* Tieoffs

.ends
