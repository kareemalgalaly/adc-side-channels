* control.spice
* File autogenerated by json2spice.py

* Standard Cell Includes
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/clkinv/sky130_fd_sc_hs__clkinv_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/and3/sky130_fd_sc_hs__and3_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nand3/sky130_fd_sc_hs__nand3_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nor2b/sky130_fd_sc_hs__nor2b_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/or2/sky130_fd_sc_hs__or2_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/o21ai/sky130_fd_sc_hs__o21ai_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nor2/sky130_fd_sc_hs__nor2_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nand2b/sky130_fd_sc_hs__nand2b_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/a21oi/sky130_fd_sc_hs__a21oi_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nor4/sky130_fd_sc_hs__nor4_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/o21bai/sky130_fd_sc_hs__o21bai_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nor3/sky130_fd_sc_hs__nor3_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/a211o/sky130_fd_sc_hs__a211o_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/o21a/sky130_fd_sc_hs__o21a_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/a211oi/sky130_fd_sc_hs__a211oi_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/and4/sky130_fd_sc_hs__and4_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/a31oi/sky130_fd_sc_hs__a31oi_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/dfxtp/sky130_fd_sc_hs__dfxtp_1.spice

* Subcircuit Definition
.subckt control clk rstn comp_out restart ramp_reset ramp_en busy valid count.0 count.1 count.2 count.3 count.4 count.5 count.6 count.7 VGND VNB VPB VPWR

* Standard Cells
x__0__ 11 VGND VNB VPB VPWR 18 sky130_fd_sc_hs__clkinv_1
x__1__ 10 VGND VNB VPB VPWR 19 sky130_fd_sc_hs__clkinv_1
x__2__ 3 VGND VNB VPB VPWR 20 sky130_fd_sc_hs__clkinv_1
x__3__ 3 4 21 VGND VNB VPB VPWR 22 sky130_fd_sc_hs__and3_1
x__4__ 3 5 23 VGND VNB VPB VPWR 24 sky130_fd_sc_hs__nand3_1
x__5__ 24 VGND VNB VPB VPWR 25 sky130_fd_sc_hs__clkinv_1
x__6__ 4 21 VGND VNB VPB VPWR 26 sky130_fd_sc_hs__nor2b_1
x__7__ 27 26 VGND VNB VPB VPWR 28 sky130_fd_sc_hs__or2_1
x__8__ 27 26 3 VGND VNB VPB VPWR 29 sky130_fd_sc_hs__o21ai_1
x__9__ 29 VGND VNB VPB VPWR 30 sky130_fd_sc_hs__clkinv_1
x__10__ 31 32 VGND VNB VPB VPWR 33 sky130_fd_sc_hs__nor2_1
x__11__ 5 23 VGND VNB VPB VPWR 34 sky130_fd_sc_hs__nand2b_1
x__12__ 33 34 20 VGND VNB VPB VPWR 35 sky130_fd_sc_hs__a21oi_1
x__13__ 3 27 VGND VNB VPB VPWR 6 sky130_fd_sc_hs__or2_1
x__14__ 3 21 VGND VNB VPB VPWR 7 sky130_fd_sc_hs__nor2b_1
x__15__ 21 31 32 27 VGND VNB VPB VPWR 36 sky130_fd_sc_hs__nor4_1
x__16__ 3 36 VGND VNB VPB VPWR 8 sky130_fd_sc_hs__nor2_1
x__17__ 3 31 VGND VNB VPB VPWR 9 sky130_fd_sc_hs__nor2b_1
x__18__ 25 30 22 VGND VNB VPB VPWR 37 sky130_fd_sc_hs__o21bai_1
x__19__ 3 28 35 VGND VNB VPB VPWR 38 sky130_fd_sc_hs__a21oi_1
x__20__ 30 35 37 VGND VNB VPB VPWR 39 sky130_fd_sc_hs__nor3_1
x__21__ 24 29 19 22 VGND VNB VPB VPWR 40 sky130_fd_sc_hs__a211o_1
x__22__ 37 38 VGND VNB VPB VPWR 41 sky130_fd_sc_hs__nor2_1
x__23__ 10 41 40 VGND VNB VPB VPWR 42 sky130_fd_sc_hs__o21a_1
x__24__ 18 38 40 VGND VNB VPB VPWR 43 sky130_fd_sc_hs__nor3_1
x__25__ 18 40 43 39 VGND VNB VPB VPWR 44 sky130_fd_sc_hs__a211oi_1
x__26__ 12 43 39 VGND VNB VPB VPWR 45 sky130_fd_sc_hs__o21bai_1
x__27__ 12 43 45 VGND VNB VPB VPWR 46 sky130_fd_sc_hs__a21oi_1
x__28__ 13 12 43 VGND VNB VPB VPWR 47 sky130_fd_sc_hs__and3_1
x__29__ 12 43 13 VGND VNB VPB VPWR 48 sky130_fd_sc_hs__a21oi_1
x__30__ 39 47 48 VGND VNB VPB VPWR 49 sky130_fd_sc_hs__nor3_1
x__31__ 14 13 12 43 VGND VNB VPB VPWR 50 sky130_fd_sc_hs__and4_1
x__32__ 14 47 VGND VNB VPB VPWR 51 sky130_fd_sc_hs__nor2_1
x__33__ 39 50 51 VGND VNB VPB VPWR 52 sky130_fd_sc_hs__nor3_1
x__34__ 15 50 39 VGND VNB VPB VPWR 53 sky130_fd_sc_hs__o21bai_1
x__35__ 15 50 53 VGND VNB VPB VPWR 54 sky130_fd_sc_hs__a21oi_1
x__36__ 16 15 50 VGND VNB VPB VPWR 55 sky130_fd_sc_hs__and3_1
x__37__ 15 50 16 VGND VNB VPB VPWR 56 sky130_fd_sc_hs__a21oi_1
x__38__ 39 55 56 VGND VNB VPB VPWR 57 sky130_fd_sc_hs__nor3_1
x__39__ 17 16 15 50 VGND VNB VPB VPWR 58 sky130_fd_sc_hs__and4_1
x__40__ 16 15 50 17 VGND VNB VPB VPWR 59 sky130_fd_sc_hs__a31oi_1
x__41__ 39 58 59 VGND VNB VPB VPWR 60 sky130_fd_sc_hs__nor3_1
x__42__ 2 20 VGND VNB VPB VPWR 32 sky130_fd_sc_hs__dfxtp_1
x__43__ 2 22 VGND VNB VPB VPWR 31 sky130_fd_sc_hs__dfxtp_1
x__44__ 2 25 VGND VNB VPB VPWR 27 sky130_fd_sc_hs__dfxtp_1
x__45__ 2 35 VGND VNB VPB VPWR 23 sky130_fd_sc_hs__dfxtp_1
x__46__ 2 30 VGND VNB VPB VPWR 21 sky130_fd_sc_hs__dfxtp_1
x__47__ 2 42 VGND VNB VPB VPWR 10 sky130_fd_sc_hs__dfxtp_1
x__48__ 2 44 VGND VNB VPB VPWR 11 sky130_fd_sc_hs__dfxtp_1
x__49__ 2 46 VGND VNB VPB VPWR 12 sky130_fd_sc_hs__dfxtp_1
x__50__ 2 49 VGND VNB VPB VPWR 13 sky130_fd_sc_hs__dfxtp_1
x__51__ 2 52 VGND VNB VPB VPWR 14 sky130_fd_sc_hs__dfxtp_1
x__52__ 2 54 VGND VNB VPB VPWR 15 sky130_fd_sc_hs__dfxtp_1
x__53__ 2 57 VGND VNB VPB VPWR 16 sky130_fd_sc_hs__dfxtp_1
x__54__ 2 60 VGND VNB VPB VPWR 17 sky130_fd_sc_hs__dfxtp_1

* Tieoffs
v__0__ VGND state_d.3 DC 0
v__1__ VGND state_d.4 DC 0
v__2__ VGND state_d.5 DC 0
v__3__ VGND state_d.6 DC 0
v__4__ VGND state_d.7 DC 0
v__5__ VGND state_d.8 DC 0
v__6__ VGND state_d.9 DC 0
v__7__ VGND state_d.10 DC 0
v__8__ VGND state_d.11 DC 0
v__9__ VGND state_d.12 DC 0
v__10__ VGND state_d.13 DC 0
v__11__ VGND state_d.14 DC 0
v__12__ VGND state_d.15 DC 0
v__13__ VGND state_d.16 DC 0
v__14__ VGND state_d.17 DC 0
v__15__ VGND state_d.18 DC 0
v__16__ VGND state_d.19 DC 0
v__17__ VGND state_d.20 DC 0
v__18__ VGND state_d.21 DC 0
v__19__ VGND state_d.22 DC 0
v__20__ VGND state_d.23 DC 0
v__21__ VGND state_d.24 DC 0
v__22__ VGND state_d.25 DC 0
v__23__ VGND state_d.26 DC 0
v__24__ VGND state_d.27 DC 0
v__25__ VGND state_d.28 DC 0
v__26__ VGND state_d.29 DC 0
v__27__ VGND state_d.30 DC 0
v__28__ VGND state_d.31 DC 0

.ends
