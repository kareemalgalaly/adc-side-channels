* SPICE netlist generated by Yosys 0.46 (git sha1 e97731b9d, clang++ 16.0.0 -fPIC -O3)

X0 count.1 1 sky130_fd_sc_hs__clkinv_1
X1 count.0 2 sky130_fd_sc_hs__clkinv_1
X2 rstn 3 sky130_fd_sc_hs__clkinv_1
X3 rstn comp_out state_q.4 state_d.2 sky130_fd_sc_hs__and3_1
X4 rstn restart state_q.3 4 sky130_fd_sc_hs__nand3_1
X5 4 5 sky130_fd_sc_hs__clkinv_1
X6 comp_out 6 state_q.4 sky130_fd_sc_hs__nor2b_1
X7 state_q.2 6 7 sky130_fd_sc_hs__or2_1
X8 8 state_q.2 6 rstn sky130_fd_sc_hs__o21ai_1
X9 8 9 sky130_fd_sc_hs__clkinv_1
X10 state_q.1 state_q.0 10 sky130_fd_sc_hs__nor2_1
X11 state_q.3 11 restart sky130_fd_sc_hs__nand2b_1
X12 12 10 11 3 sky130_fd_sc_hs__a21oi_1
X13 rstn state_q.2 ramp_reset sky130_fd_sc_hs__or2_1
X14 rstn ramp_en state_q.4 sky130_fd_sc_hs__nor2b_1
X15 state_q.4 state_q.1 state_q.0 state_q.2 13 sky130_fd_sc_hs__nor4_1
X16 rstn 13 busy sky130_fd_sc_hs__nor2_1
X17 rstn valid state_q.1 sky130_fd_sc_hs__nor2b_1
X18 14 5 9 state_d.2 sky130_fd_sc_hs__o21bai_1
X19 15 rstn 7 12 sky130_fd_sc_hs__a21oi_1
X20 9 12 14 16 sky130_fd_sc_hs__nor3_1
X21 17 4 8 2 state_d.2 sky130_fd_sc_hs__a211o_1
X22 14 15 18 sky130_fd_sc_hs__nor2_1
X23 19 count.0 18 17 sky130_fd_sc_hs__o21a_1
X24 1 15 17 20 sky130_fd_sc_hs__nor3_1
X25 21 1 17 20 16 sky130_fd_sc_hs__a211oi_1
X26 22 count.2 20 16 sky130_fd_sc_hs__o21bai_1
X27 23 count.2 20 22 sky130_fd_sc_hs__a21oi_1
X28 count.3 count.2 20 24 sky130_fd_sc_hs__and3_1
X29 25 count.2 20 count.3 sky130_fd_sc_hs__a21oi_1
X30 16 24 25 26 sky130_fd_sc_hs__nor3_1
X31 count.4 count.3 count.2 20 27 sky130_fd_sc_hs__and4_1
X32 count.4 24 28 sky130_fd_sc_hs__nor2_1
X33 16 27 28 29 sky130_fd_sc_hs__nor3_1
X34 30 count.5 27 16 sky130_fd_sc_hs__o21bai_1
X35 31 count.5 27 30 sky130_fd_sc_hs__a21oi_1
X36 count.6 count.5 27 32 sky130_fd_sc_hs__and3_1
X37 33 count.5 27 count.6 sky130_fd_sc_hs__a21oi_1
X38 16 32 33 34 sky130_fd_sc_hs__nor3_1
X39 count.7 count.6 count.5 27 35 sky130_fd_sc_hs__and4_1
X40 36 count.6 count.5 count.7 27 sky130_fd_sc_hs__a31oi_1
X41 16 35 36 37 sky130_fd_sc_hs__nor3_1
X42 clk 3 state_q.0 sky130_fd_sc_hs__dfxtp_1
X43 clk state_d.2 state_q.1 sky130_fd_sc_hs__dfxtp_1
X44 clk 5 state_q.2 sky130_fd_sc_hs__dfxtp_1
X45 clk 12 state_q.3 sky130_fd_sc_hs__dfxtp_1
X46 clk 9 state_q.4 sky130_fd_sc_hs__dfxtp_1
X47 clk 19 count.0 sky130_fd_sc_hs__dfxtp_1
X48 clk 21 count.1 sky130_fd_sc_hs__dfxtp_1
X49 clk 23 count.2 sky130_fd_sc_hs__dfxtp_1
X50 clk 26 count.3 sky130_fd_sc_hs__dfxtp_1
X51 clk 29 count.4 sky130_fd_sc_hs__dfxtp_1
X52 clk 31 count.5 sky130_fd_sc_hs__dfxtp_1
X53 clk 34 count.6 sky130_fd_sc_hs__dfxtp_1
X54 clk 37 count.7 sky130_fd_sc_hs__dfxtp_1
V0 Vss state_d.3 DC 0
V1 Vss state_d.4 DC 0
V2 Vss state_d.5 DC 0
V3 Vss state_d.6 DC 0
V4 Vss state_d.7 DC 0
V5 Vss state_d.8 DC 0
V6 Vss state_d.9 DC 0
V7 Vss state_d.10 DC 0
V8 Vss state_d.11 DC 0
V9 Vss state_d.12 DC 0
V10 Vss state_d.13 DC 0
V11 Vss state_d.14 DC 0
V12 Vss state_d.15 DC 0
V13 Vss state_d.16 DC 0
V14 Vss state_d.17 DC 0
V15 Vss state_d.18 DC 0
V16 Vss state_d.19 DC 0
V17 Vss state_d.20 DC 0
V18 Vss state_d.21 DC 0
V19 Vss state_d.22 DC 0
V20 Vss state_d.23 DC 0
V21 Vss state_d.24 DC 0
V22 Vss state_d.25 DC 0
V23 Vss state_d.26 DC 0
V24 Vss state_d.27 DC 0
V25 Vss state_d.28 DC 0
V26 Vss state_d.29 DC 0
V27 Vss state_d.30 DC 0
V28 Vss state_d.31 DC 0

************************
* end of SPICE netlist *
************************
