/Users/kareemahmad/Projects/SideChannels/SingleSlopeADC_Mixed/synth/control_v0_wrap
* File Autogenerated by synth_post.py
.lib "/Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_pr/models/sky130.lib.spice" tt
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/dfxtp/sky130_fd_sc_hs__dfxtp_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/clkinv/sky130_fd_sc_hs__clkinv_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/and3/sky130_fd_sc_hs__and3_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/a21oi/sky130_fd_sc_hs__a21oi_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nand3/sky130_fd_sc_hs__nand3_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/a211o/sky130_fd_sc_hs__a211o_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/a211oi/sky130_fd_sc_hs__a211oi_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/a31oi/sky130_fd_sc_hs__a31oi_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/o21a/sky130_fd_sc_hs__o21a_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/o21ai/sky130_fd_sc_hs__o21ai_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nor3/sky130_fd_sc_hs__nor3_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nor2b/sky130_fd_sc_hs__nor2b_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nor4/sky130_fd_sc_hs__nor4_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/and4/sky130_fd_sc_hs__and4_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nand2b/sky130_fd_sc_hs__nand2b_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/nor2/sky130_fd_sc_hs__nor2_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/or2/sky130_fd_sc_hs__or2_1.spice
.include /Users/kareemahmad/Lib/efabless/skywater-pdk-libs-sky130_fd_sc_hs/cells/o21bai/sky130_fd_sc_hs__o21bai_1.spice

.subckt /Users/kareemahmad/Projects/SideChannels/SingleSlopeADC_Mixed/synth/control_v0_wrap clk comp_out restart rstn busy count.0 count.1 count.2 count.3 count.4 count.5 count.6 count.7 ramp_en ramp_reset valid
.include /Users/kareemahmad/Projects/SideChannels/SingleSlopeADC_Mixed/synth/control_v0.spice
.ends
